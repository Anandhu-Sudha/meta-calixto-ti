FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Use an override for your specific machine to point to the file directly
SRC_URI:am62lxx-stamp-lpddr = "file://uEnv-am62l-sk.txt"
